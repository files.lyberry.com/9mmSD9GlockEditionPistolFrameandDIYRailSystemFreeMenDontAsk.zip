SD9 Angle v3 (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Frame", "Alu1", "Alu2"